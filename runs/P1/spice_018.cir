DENV 0 1 0.7 0.3
C1 1 0 1e-6
R1 1 0 -10k
V1 0 0 5
